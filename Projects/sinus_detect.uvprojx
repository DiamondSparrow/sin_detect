# Keil uVision project sinus_detect.uvprojx, settings and files
target Develop (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC11U68JBD64 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x0800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sinus_detect
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CORE_M0PLUS
  c include: C:\Keil_v5\ARM\ARMCC\include;..\Code\APP;..\Code\ThirdParty\CMSIS\Includes;..\Code\ThirdParty\CMSIS\RTOS\Includes;..\Code\ThirdParty\CMSIS\RTOS\RTX\Config;..\Code\ThirdParty\CMSIS\RTOS\RTX\Includes;..\Code\ThirdParty\lpcopen\lpc_chip\chip_11u6x;..\Code\ThirdParty\lpcopen\lpc_chip\chip_11u6x\config_11U6X;..\Code\ThirdParty\lpcopen\lpc_chip\chip_common;..\Code\Utils
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x800
  group APP
    ../Code/APP/: app.c debug.c filters.c sin_detect.c
  group APP/BSP
    ../Code/APP/bsp/: bsp.c faults.c
  group APP/BSP/Device
    ../Code/APP/bsp/device/: system_LPC11U6x.c startup_LPC11U6x.s
  group APP/BSP/Periph
    ../Code/APP/bsp/periph/: adc.c gpio.c timers.c uart.c wdt.c
  group ThirdParty/CMSIS-RTOS
    ../Code/ThirdParty/CMSIS/RTOS/RTX/Config/: RTX_Config.h RTX_Config.c
    ../Code/ThirdParty/CMSIS/RTOS/RTX/Library/: RTX_CM0.lib
    ../Code/ThirdParty/CMSIS/RTOS/RTX/Source/: rtx_lib.c
  group ThirdParty/lpcopen/chip_11u6x
    ../Code/ThirdParty/lpcopen/lpc_chip/chip_11u6x/: adc_11u6x.c chip_11u6x.c clock_11u6x.c crc_11u6x.c dma_11u6x.c gpio_11u6x.c gpiogroup_11u6x.c i2c_11u6x.c i2cm_11u6x.c iocon_11u6x.c pinint_11u6x.c pmu_11u6x.c romdiv_11u6x.c rtc_11u6x.c sct_11u6x.c syscon_11u6x.c sysinit_11u6x.c ssp_11u6x.c stopwatch_11u6.c timer_11u6x.c uart_0_11u6x.c uart_n_11u6x.c wwdt_11u6x.c
  group ThirdParty/lpcopen/chip/common
    ../Code/ThirdParty/lpcopen/lpc_chip/chip_common/: ring_buffer.c
